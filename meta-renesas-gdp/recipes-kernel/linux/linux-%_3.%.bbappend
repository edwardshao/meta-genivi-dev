FILESEXTRAPATHS_prepend := "${THISDIR}/linux:"

SRC_URI += " \
    file://netfilter.cfg \
"
